CHUMBYSG_GIT_HOST = "git://github.com/sutajiokousagi"
CHUMBYSG_GIT_PROTOCOL = "http"
CHUMBYSG_GIT_EXTENSION = ".git"
