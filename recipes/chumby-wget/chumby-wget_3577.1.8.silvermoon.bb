require chumby-wget.inc
