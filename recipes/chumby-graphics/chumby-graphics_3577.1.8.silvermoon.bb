require chumby-graphics.inc
COMPATIBLE_MACHINE = "chumby-silvermoon"
PROVIDES = "chumby-graphics"
