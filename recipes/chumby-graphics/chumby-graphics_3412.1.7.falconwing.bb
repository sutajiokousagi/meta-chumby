require chumby-graphics.inc
COMPATIBLE_MACHINE = "chumby-falconwing"
PROVIDES = "chumby-graphics"
