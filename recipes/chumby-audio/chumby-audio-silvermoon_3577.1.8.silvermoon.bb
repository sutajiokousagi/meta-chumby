require chumby-audio.inc
COMPATIBLE_MACHINE = "chumby-silvermoon-*"
PROVIDES = "chumby-audio"
