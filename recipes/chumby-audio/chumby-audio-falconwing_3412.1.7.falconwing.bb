require chumby-audio.inc
COMPATIBLE_MACHINE = "chumby-falconwing"
PROVIDES = "chumby-audio"
