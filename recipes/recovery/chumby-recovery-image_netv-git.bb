inherit image

PREFERRED_PROVIDER_virtual/libsdl = "libsdl-chumby-simple"
ANGSTRO_BLACKLIST_pn-libsdl-x11 = "WTF?"

COMPATIBLE_MACHINE = "chumby-silvermoon-netv"
ONLINE_PACKAGE_MANAGEMENT = "none"
IMAGE_FSTYPES = "cpio"
IMAGE_DEV_MANAGER = ""
IMAGE_LINGUAS = ""

MACHINE_POSTPROCESS_COMMAND = ""

IMAGE_INSTALL = "netv-recovery"
