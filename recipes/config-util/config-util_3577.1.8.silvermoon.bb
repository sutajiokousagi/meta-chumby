require config-util.inc
