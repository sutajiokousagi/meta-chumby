inherit native
require config-util.inc
