SRCREV = "241261ec80f9c8d32ded37971fa7bff002d77bdc"
inherit native
require config-util-native.inc
