require chumby-psp.inc
COMPATIBLE_MACHINE = "chumby-falconwing"
PROVIDES = "chumby-psp"
