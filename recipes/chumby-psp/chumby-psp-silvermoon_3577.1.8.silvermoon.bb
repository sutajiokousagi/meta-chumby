require chumby-psp.inc
COMPATIBLE_MACHINE = "chumby-silvermoon-*"
PROVIDES = "chumby-psp"
