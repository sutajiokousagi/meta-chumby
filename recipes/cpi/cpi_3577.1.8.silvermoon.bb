require cpi.inc
