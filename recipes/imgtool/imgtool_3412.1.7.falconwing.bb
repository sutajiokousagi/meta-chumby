SRCREV = "37bae1c3e9543b86be01055abc92794639efb5a9"
require imgtool.inc
