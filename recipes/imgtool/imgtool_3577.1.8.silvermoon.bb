SRCREV = "9ee0c24c39175ad9199671411b02755d087fb8b6"
require imgtool.inc
